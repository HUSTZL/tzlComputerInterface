ORG 0100H

MOV DX, 08CBH
MOV AL, 80H
OUT DX, AL

MOV AX, 0
LOOPA:CMP AX, 10000
JNZ DISPA
MOV AX, 0

DISPA:MOV CX, 300H
DISP:MOV SI, AX

MOV BX, 0AH
MOV DX, 0
DIV BX
MOV DI, AX
CALL GET_NUM
MOV DX, 08CAH
MOV BX, AX
MOV AL, 0FEH
OUT DX, AL
MOV AX, BX
MOV DX, 08C8H
OUT DX, AL
CALL DIAP
MOV AX, DI

MOV BX, 0AH
MOV DX, 0
DIV BX
MOV DI, AX
CALL GET_NUM
MOV DX, 08CAH
MOV BX, AX
MOV AL, 0FDH
OUT DX, AL
MOV AX, BX
MOV DX, 08C8H
OUT DX, AL
CALL DIAP
MOV AX, DI

MOV BX, 0AH
MOV DX, 0
DIV BX
MOV DI, AX
CALL GET_NUM
MOV DX, 08CAH
MOV BX, AX
MOV AL, 0FBH
OUT DX, AL
MOV AX, BX
MOV DX, 08C8H
OUT DX, AL
CALL DIAP
MOV AX, DI

MOV BX, 0AH
MOV DX, 0
DIV BX
MOV DI, AX
CALL GET_NUM
MOV DX, 08CAH
MOV BX, AX
MOV AL, 0F7H
OUT DX, AL
MOV AX, BX
MOV DX, 08C8H
OUT DX, AL
CALL DIAP
MOV AX, DI

MOV AX, SI
DEC CX
CMP CX, 0
JE OUTLOOP
JMP DISP

OUTLOOP:INC AX
JMP LOOPA

GET_NUM:
CMP DX, 0
JNZ NEQ0
MOV AL, 3FH
NEQ0:CMP DX, 1
JNZ NEQ1
MOV AL, 06H
NEQ1:CMP DX, 2
JNZ NEQ2
MOV AL, 5BH
NEQ2:CMP DX, 3
JNZ NEQ3
MOV AL, 4FH
NEQ3:CMP DX, 4
JNZ NEQ4
MOV AL, 66H
NEQ4:CMP DX, 5
JNZ NEQ5
MOV AL, 6DH
NEQ5:CMP DX, 6
JNZ NEQ6
MOV AL, 7DH
NEQ6:CMP DX, 7
JNZ NEQ7
MOV AL, 07H
NEQ7:CMP DX, 8
JNZ NEQ8
MOV AL, 7FH
NEQ8:CMP DX, 9
JNZ NEQ9
MOV AL, 6FH
NEQ9:MOV DX, 0
RET

DIAP:MOV AL, 0
OUT DX, AL
RET